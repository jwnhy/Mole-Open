## mcu_hacker/Kconfig
```kconfig
menu "MCU Hacker Module"
config MCU_HACKER
 tristate "MCU Hacker Module"
 default m
endmenu
```
